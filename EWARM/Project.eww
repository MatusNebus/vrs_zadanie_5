<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\vrs_zadanie_5.ewp</path>
  </project>
  <batchBuild />
</workspace>
