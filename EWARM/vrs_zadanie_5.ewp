# IAR project vrs_zadanie_5.ewp, settings and files
configuration vrs_zadanie_5 (ARM, debug)
  General.OGChipSelectEditMenu: STM32F303K8 ST STM32F303K8
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 59
  General.FPU2: 6
  ICCARM.CCDefines: USE_FULL_LL_DRIVER; HSE_VALUE=8000000; HSE_STARTUP_TIMEOUT=100; LSE_STARTUP_TIMEOUT=5000; LSE_VALUE=32768; EXTERNAL_CLOCK_VALUE=8000000; HSI_VALUE=8000000; LSI_VALUE=40000; VDD_VALUE=3300; PREFETCH_ENABLE=1; STM32F303x8
  ICCARM.CCIncludePath2: ../Core/Inc; ../Drivers/STM32F3xx_HAL_Driver/Inc; ../Drivers/CMSIS/Device/ST/STM32F3xx/Include; ../Drivers/CMSIS/Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: vrs_zadanie_5.hex
  ILINK.IlinkOutputFile: vrs_zadanie_5.out
  ILINK.IlinkIcfFile: stm32f303x8_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32f303x8.s
  group Application/User/Core
    ../Core/Src/: main.c stm32f3xx_it.c
  group Drivers/STM32F3xx_HAL_Driver
    ../Drivers/STM32F3xx_HAL_Driver/Src/: stm32f3xx_ll_utils.c stm32f3xx_ll_exti.c stm32f3xx_ll_gpio.c stm32f3xx_ll_rcc.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f3xx.c
